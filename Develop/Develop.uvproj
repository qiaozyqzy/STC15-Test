# Keil uVision project Develop.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Develop +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\HARDWARE
  link misc: REMOVEUNUSED
  group USER
    ./USER/: MAIN.c
  group HARDWARE
    ./HARDWARE/: DEBUG.c DELAY.c EXINT.C GPIO.C MY_STUDIO.C nRF24L01.c nRF24L01_UI.c STC15_SPI.c SYS.c UART.C I2C.C OLED.c Font_CHS.c Font_EN.c Font_PIC.c
